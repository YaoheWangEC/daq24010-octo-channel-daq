# Keil uVision project daq2401x-octo-channel-daq-f415cbt7.uvprojx, settings and files
target daq2401x-octo-channel-daq-f415cbt7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F415CBT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.1.8
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: daq2401x-octo-channel-daq-f415cbt7 +hex
  AfterMake: Keil-build-viewer.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F415CBT7, USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;.\daq2401x;.\daq2401x\bsp;.\daq2401x\command;.\daq2401x\bsp\lcd;../../middlewares/i2c_application_library
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ./daq2401x/: global_vars.c user.c ringbuf.c
  group bsp
    ./daq2401x/bsp/: bsp.c rgbled.c key.c
    ./daq2401x/bsp/lcd/: colorlut.c lcd.c lcd_io.c lcdfont.c
  group user
    ../src/: main.c at32f415_wk_config.c at32f415_int.c wk_system.c i2c_app.c wk_adc.c wk_debug.c wk_i2c.c wk_spi.c wk_tmr.c wk_usart.c wk_dma.c wk_gpio.c eeprom.c wk_wdt.c
  group firmware
    ../../libraries/drivers/src/: at32f415_adc.c at32f415_crm.c at32f415_debug.c at32f415_dma.c at32f415_flash.c at32f415_gpio.c at32f415_i2c.c at32f415_misc.c at32f415_pwc.c at32f415_spi.c at32f415_tmr.c at32f415_usart.c at32f415_wdt.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f415.c
    ./: startup_at32f415.s
  group middlewares/i2c_application
    ../../middlewares/i2c_application_library/: i2c_application.c
  group command
    ./daq2401x/command/: command_fifo.c command_handler.c command_io.c command_io_uart.c command_parser.c command_table.c
